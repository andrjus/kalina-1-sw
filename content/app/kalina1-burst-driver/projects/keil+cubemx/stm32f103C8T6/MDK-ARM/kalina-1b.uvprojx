# Keil uVision project kalina-1b.uvprojx, settings and files
target kalina-1b (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KALINA-1-BETA-MYTECH-8085-HA-CCE +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,K1_TAG_BOARD_BETA,K1_TAG_MYTECH_8085_HA_CCE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../../../../../reference/robosd-ref;../../../../../../reference/robosd-ref/burst/platform/keil;../../../../source/common;../../../../source/platform/keil+cubemx/stm32f103CBt6
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group robosd++/burst
    ../../../../../../reference/robosd-ref/burst/: burst.c burst.h burst_adc.c burst_adc.h burst_app.h burst_button.c burst_button.h burst_common.h burst_enco.h burst_filter.h burst_fm.c burst_fm.h burst_front.h burst_hall.c burst_hall.h burst_inv3ph.c burst_inv3ph.h burst_motion.c burst_motion.h burst_pi.c burst_pi.h burst_positioner.c burst_positioner.h burst_ps.c burst_ring.inc.h burst_serial.c burst_serial.h burst_signal.c burst_signal.h burst_sin.c burst_sin.h burst_timer.c burst_timer.h burst_ps.h burst_sqrt.c burst_sqrt.h
  group robosd++/burst/platform
    ../../../../../../reference/robosd-ref/burst/platform/keil/: burst_target.h
  group common
    ../../../../source/common/: k1-burst-driver.c k1-burst-driver.common.h k1-burst-driver.h k1-burst-driver.names.h k1-burst-driver.obj.c
  group platform
    ../../../../source/platform/keil+cubemx/stm32f103CBt6/: burst_app_tuning.h k1-burst-driver.pfr.c
  group robosd++/burst/cliche
    ../../../../../../reference/robosd-ref/burst/cliche/: _begin.h _end.h clch_test.c fm.h ps.h tp.h net_master.h swt.c swt.h
  group robosd++/burst/modules
    ../../../../../../reference/robosd-ref/burst/modules/: actuator.c actuator.h actuator_front.h acwc.c acwc.h acwc_front.h enco_abs32.c enco_abs32.h nikitin.c nikitin.h pmsm.c pmsm.h pmsm_front.h pmsm_hall_app.c pmsm_hall_app.h pmsm_hall_app.obj.c ps_dc.c ps_dc.h
  group common/machine
    ../../../../source/common/machines/: k1-A60-7M.motor.config.h k1-beta.pfr.config.h k1-MYTECH-8085-HA-CCE.motor.config.h
software components: CMSIS:CORE 5.6.0
