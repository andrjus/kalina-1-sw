# Keil uVision project kalina-1-burst-driver.uvprojx, settings and files
target kalina-1-burst-driver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x805FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: kalina-1-burst +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103x6,K1_TAG_A60_7M
  c misc: --gnu
  c include: ../Core/Inc;../../../../../../reference/robosd-ref;../../../../../../reference/robosd-ref/burst/platform/keil;../../../../source/common;../../../../source/platform/keil+cubemx/stm32f103c6t6;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group robosd++/burst
    ../../../../../../reference/robosd-ref/burst/: burst.h burst_app.h burst_button.h burst_enco.h burst_filter.h burst_front.h burst_motion.h burst_positioner.h burst_proto.h burst_ring.inc.h burst_serial.h burst_signal.h burst_sin.h burst_timer.h burst.c burst_button.c burst_motion.c burst_positioner.c burst_serial.c burst_signal.c burst_sin.c burst_timer.c burst_common.h burst_hall.h burst_hall.c burst_adc.h burst_adc.c burst_pi.c burst_pi.h burst_ps.c burst_ps.h
  group robosd++/burst/platform
    ../../../../../../reference/robosd-ref/burst/platform/keil/: burst_target.h
  group platform
    ../../../../source/platform/keil+cubemx/stm32f103c6t6/: burst_app_tuning.h k1-burst-driver.pfr.c
  group common
    ../../../../source/common/: k1-burst-driver.common.h k1-burst-driver.names.h k1-burst-driver.h k1-burst-driver.c k1-burst-driver.obj.c
  group robosd++/burst/cliche
    ../../../../../../reference/robosd-ref/burst/cliche/: _begin.h _end.h tp.h clch_test.c fm.h ps.h
  group burst/modules
    ../../../../../../reference/robosd-ref/burst/modules/: nikitin.c nikitin.h pmsm_hall_app.c pmsm_hall_app.h pmsm_hall_app.obj.c actuator.c actuator.h actuator_front.h acwc.c acwc.h acwc_front.h enco_abs32.c enco_abs32.h pmsm.c pmsm.h pmsm_front.h
    ../../../../../../reference/robosd-ref/burst/: burst_inv3ph.c burst_inv3ph.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_crc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group common/machines
    ../../../../source/common/machines/: k1-A60-7M.motor.config.h k1-A60-7M.pfr.config.h
software components: CMSIS:CORE 5.6.0
