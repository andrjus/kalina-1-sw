# Keil uVision project kiparis-2.uvprojx, settings and files
target kiparis-2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: kparys-2-AT38-12 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,K1_TAG_BOARD_KIPARIS_2, K1_TAG_KIPARIS_2_AT_38_12,STM32F405xx
  c include: ../Core/Inc;../Drivers/CMSIS/Include;../../../../../../reference/robosd-ref;../../../../../../reference/robosd-ref/burst/platform/keil;../../../../source/common;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../source/platform/keil+cubemx/kiparis2-stm32f405rgt6
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group robosd++/burst
    ../../../../../../reference/robosd-ref/burst/: burst.c burst.h burst_adc.c burst_adc.h burst_app.h burst_button.c burst_button.h burst_common.h burst_enco.h burst_filter.h burst_fm.c burst_fm.h burst_front.h burst_hall.c burst_hall.h burst_inv3ph.c burst_inv3ph.h burst_motion.c burst_motion.h burst_pi.c burst_pi.h burst_positioner.c burst_positioner.h burst_ps.c burst_ps.h burst_ring.inc.h burst_serial.c burst_serial.h burst_signal.c burst_signal.h burst_sin.c burst_sin.h burst_timer.c burst_timer.h burst_sqrt.c burst_sqrt.h
  group robosd++/burst/platform
    ../../../../../../reference/robosd-ref/burst/platform/keil/: burst_target.h
  group common
    ../../../../source/common/: k1-burst-driver.c k1-burst-driver.common.h k1-burst-driver.h k1-burst-driver.names.h k1-burst-driver.obj.c
  group platform
    ../../../../source/platform/keil+cubemx/kiparis2-stm32f405rgt6/: burst_app_tuning.h kiparis-2-burst-driver.pfr.c
  group robosd++/burst/cliche
    ../../../../../../reference/robosd-ref/burst/cliche/: _begin.h _end.h clch_test.c fm.h ps.h tp.h net_master.h swt.h swt.c
  group robosd++/burst/modules
    ../../../../../../reference/robosd-ref/burst/modules/: actuator.c actuator.h actuator_front.h acwc.c acwc.h acwc_front.h enco_abs32.c enco_abs32.h nikitin.c nikitin.h pmsm.c pmsm.h pmsm_front.h pmsm_hall_app.c pmsm_hall_app.h pmsm_hall_app.obj.c ps_dc.c ps_dc.h
  group common/machine
    ../../../../source/common/machines/: k1-kiparis2.pfr.config.h k1-kiparis2-AT38-12.motor.config.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
target kiparis-2A (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: kparys-2A-AT38-12 +hex
  c flags: as above
  c define: USE_HAL_DRIVER,K1_TAG_BOARD_KIPARIS_2A, K1_TAG_KIPARIS_2_AT_38_12,STM32F405xx
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
software components: CMSIS:CORE 4.3.0
